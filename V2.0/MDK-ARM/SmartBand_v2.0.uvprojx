# Keil uVision project SmartBand_v2.0.uvprojx, settings and files
target SamaritanProject (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SmartBand_v2.0.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\Drivers\STM32L0xx_HAL_Driver\Inc;..\Drivers\BSP\STM32L0xx_Nucleo;..\Drivers\BSP\Adafruit_Shield;..\Drivers\BSP\Components\Common;..\Drivers\BSP\Components\st7735;..\Users\Inc;..\Threshold_Drivers\Inc;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\FreeRTOS\Source\CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Doc
    ../Document/: readme.txt
  group Drivers/CMSIS
    ../Users/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group User
    ../Users/Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c User_ISR.c User_DataToPC.c User_MPU_Count.c User_Menu.c User_AD.c
  group MDK-ARM
    ./: startup_stm32l053xx.s
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Threshold_Drivers
    ../Threshold_Drivers/Src/: Threshold_GPIO.c Threshold_SYS.c Threshold_UART.c Threshold_Timer.c Threshold_RTC.c Threshold_MPU6050.c Threshold_I2C.c Threshold_GpioI2C.c Threshold_OLED.c Threshold_MMA9553L.c Threshold_PulseSensor.c Threshold_ADC.c
  group System/FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group System/FreeRTOS/portable
    ../FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group System/FreeRTOS/CMSIS_RTOS
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 3.40.0
