<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>FLASH_128KB</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FLASH_64KB</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FLASH_32KB</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\alloc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\assert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\assert.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\io.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\memtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\memtest.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\queue.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\startup.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\stdlib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\stdlib.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\uif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\common\uif.h</name>
    </file>
  </group>
  <group>
    <name>cpu</name>
    <group>
      <name>headers</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\cpu\headers\MKL25Z4.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\cpu\arm_cm0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\cpu\arm_cm0.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\cpu\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\cpu\start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\cpu\start.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\cpu\sysinit.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\cpu\vectors.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\cpu\vectors.h</name>
    </file>
  </group>
  <group>
    <name>drivers</name>
    <group>
      <name>cmp</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\cmp\cmp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\cmp\cmp.h</name>
      </file>
    </group>
    <group>
      <name>llwu</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\llwu\llwu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\llwu\llwu.h</name>
      </file>
    </group>
    <group>
      <name>lptmr</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\lptmr\lptmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\lptmr\lptmr.h</name>
      </file>
    </group>
    <group>
      <name>mcg</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\mcg\mcg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\mcg\mcg.h</name>
      </file>
    </group>
    <group>
      <name>pmc</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\pmc\pmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\pmc\pmc.h</name>
      </file>
    </group>
    <group>
      <name>rcm</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\rcm\rcm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\rcm\rcm.h</name>
      </file>
    </group>
    <group>
      <name>rtc</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\rtc\rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\rtc\rtc.h</name>
      </file>
    </group>
    <group>
      <name>smc</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\smc\smc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\smc\smc.h</name>
      </file>
    </group>
    <group>
      <name>uart</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\uart\uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\drivers\uart\uart.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>IAR</name>
    <file>
      <name>$PROJ_DIR$\..\config files\128KB_Pflash.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\config files\16KB_RAM.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\config files\32KB_Pflash.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\config files\4KB_RAM.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\config files\64KB_Pflash.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\config files\8KB_RAM.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\iar.h</name>
    </file>
  </group>
  <group>
    <name>platforms</name>
  </group>
  <group>
    <name>project</name>
    <group>
      <name>anlge_calculation</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\angle_calculation\angle_cal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\angle_calculation\angle_cal.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\angle_calculation\asin.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\angle_calculation\asin.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\angle_calculation\median.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\angle_calculation\median.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\angle_calculation\sqrt16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\angle_calculation\sqrt16.h</name>
      </file>
    </group>
    <group>
      <name>bsp</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\bsp\bsp_KL25.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\bsp\bsp_KL25.h</name>
      </file>
    </group>
    <group>
      <name>freedom_gpio</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\freedom_gpio\freedom_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\freedom_gpio\freedom_gpio.h</name>
      </file>
    </group>
    <group>
      <name>I2C</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\I2C\dvMMA9553.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\I2C\hal_dev_mma8451.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\I2C\hal_dev_mma8451.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\I2C\hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\I2C\hal_i2c.h</name>
      </file>
    </group>
    <group>
      <name>pit</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\pit\pit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\pit\pit.h</name>
      </file>
    </group>
    <group>
      <name>task_mgr.c</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\task_mgr\task_mgr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\task_mgr\task_mgr.h</name>
      </file>
    </group>
    <group>
      <name>tsi</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\tsi\TSIDrv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\tsi\TSIDrv.h</name>
      </file>
    </group>
    <group>
      <name>usb</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\usb\ring_buffer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\usb\ring_buffer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\usb\usb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\usb\usb.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\usb\usb_cdc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\usb\usb_cdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\usb\usb_descriptor.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\usb\usb_reg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\usb\usb_reg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\FRDM_KL25ZDemo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\freedom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\FslTypes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\global.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\global.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\isr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\projects\FRDM_KL25ZDemo\sysinit.c</name>
    </file>
  </group>
</project>


